# Keil uVision project LedMgmtByButton.uvprojx, settings and files
target LedMgmtByButton (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MDR1986BE92 Milandr
  pack: Keil.MDR1986BExx.1.5.3
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LedMgmtByButton +hex
  c flags: Optim=1
  c include: ..\..\lib\CMSIS\CM3\DeviceSupport\MDR32F9Qx\startup;..\..\lib\CMSIS\CM3\DeviceSupport\MDR32F9Qx\inc;..\..\lib\CMSIS\CM3\DeviceSupport\MDR32F9Qx\startup\arm;..\..\lib\MDR32F9Qx_StdPeriph_Driver\inc;..\..\lib\Config
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./src/: button.c clk.c led.c main.c button.h clk.h led.h type_custom.h
  group DeviceSupport
    ../../lib/CMSIS/CM3/DeviceSupport/MDR32F9Qx/inc/: MDR32Fx.h
    ../../lib/CMSIS/CM3/DeviceSupport/MDR32F9Qx/startup/arm/: startup_MDR32F9Qx.s
    ../../lib/CMSIS/CM3/DeviceSupport/MDR32F9Qx/startup/: system_MDR32F9Qx.h system_MDR32F9Qx.c
  group StdPeriphDriver
    ../../lib/MDR32F9Qx_StdPeriph_Driver/inc/: MDR32F9Qx_port.h MDR32F9Qx_rst_clk.h
    ../../lib/MDR32F9Qx_StdPeriph_Driver/src/: MDR32F9Qx_port.c MDR32F9Qx_rst_clk.c
    ./src/: MDR32F9Qx_timer.h MDR32F9Qx_timer.c
software components: CMSIS:CORE 4.3.0
